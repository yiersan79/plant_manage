# IAR project plan_manage_main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\src\app\include; ..\src\include\common; ..\src\include\cpu; ..\src\include\drivers; ..\src\include\platforms; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: plan_manage_main.srec
  ILINK.IlinkOutputFile: plan_manage_main.out
  ILINK.IlinkIcfFile: F:\work_space\graduation_pro\plan_manage\plan_manage_main\config_files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src/app
    ../src/app/: debug.c display.c flash.c input.c isr.c key.c knob.c main.c output.c plan_handle.c pm_init.c simulat_timer.c tft.c time.c
  group src/app/include
    ../src/app/include/: config.h debug.h display.h flash.h input.h isr.h key.h knob.h output.h plan_handle.h setup.h simulat_timer.h tft.h time.h
  group src/common
    ../src/common/: alloc.c assert.c common.c io.c memtest.c printf.c queue.c startup.c uif.c
  group src/cpu
    ../src/cpu/: arm_cm0.c crt0.s start.c sysinit.c vectors.c
  group src/drivers
    ../src/drivers/: adc.c cmp.c dac.c dma.c gpio.c i2c.c lptmr.c mcg.c pit.c port.c rtc.c SPI.c systick.c tick_timer.c tpm.c tsi.c uart.c
  group src/include/common
    ../src/include/common/: assert.h common.h io.h memtest.h queue.h startup.h stdlib.h typedef.h uif.h
  group src/include/cpu
    ../src/include/cpu/: arm_cm0.h dma_channels.h MKL25Z4.h sysinit.h vectors.h
  group src/include/drivers
    ../src/include/drivers/: adc.h cmp.h dac.h dma.h fire_drivers_cfg.h Fire_kinetis_MCG_CFG.h gpio.h gpio_cfg.h i2c.h i2c_cfg.h include.h lptmr.h mcg.h mcg_cfg.h pit.h port.h rtc.h SPI.h systick.h tick_timer.h tpm.h tsi.h uart.h
  group src/include/platforms
    ../src/include/platforms/: freedom.h tower.h
  group src/other
    ../src/other/: LandzoOLED.c LandzoOLED.h
