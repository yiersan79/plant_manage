<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>src</name>
    <group>
      <name>app</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\display.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\input.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\isr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\key.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\knob.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\output.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\plan_handle.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\pm_time.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\setup.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\simulat_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\app\include\tft.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\src\app\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\display.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\input.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\isr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\knob.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\NormalDemo_Flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\output.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\plan_handle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\pm_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\pm_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\simulat_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\tft.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\src\common\alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\memtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\printf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\common\uif.c</name>
      </file>
    </group>
    <group>
      <name>cpu</name>
      <file>
        <name>$PROJ_DIR$\..\src\cpu\arm_cm0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cpu\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cpu\start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cpu\sysinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cpu\vectors.c</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>FTFx</name>
        <group>
          <name>source</name>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\CopyToRam.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\DEFlashPartition.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\DFlashGetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\DFlashSetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\EEEWrite.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\EERAMGetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\EERAMSetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashCheckSum.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashCommandSequence.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashEraseAllBlock.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashEraseBlock.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashEraseResume.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashEraseSector.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashEraseSuspend.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashGetSecurityState.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashInit.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashProgram.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashProgramCheck.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashProgramOnce.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashProgramSection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashReadOnce.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashReadResource.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashSecurityBypass.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashVerifyAllBlock.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashVerifyBlock.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\FlashVerifySection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\PFlashGetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\PFlashSetProtection.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\PFlashSwap.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\PFlashSwapCtl.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\src\drivers\FTFx\source\SetEEEEnable.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\cmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\lptmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\mcg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\pit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\SPI.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\tick_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\tpm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\tsi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\drivers\uart.c</name>
      </file>
    </group>
    <group>
      <name>include</name>
      <group>
        <name>common</name>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\assert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\io.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\memtest.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\queue.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\startup.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\stdlib.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\typedef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\common\uif.h</name>
        </file>
      </group>
      <group>
        <name>cpu</name>
        <file>
          <name>$PROJ_DIR$\..\src\include\cpu\arm_cm0.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\cpu\dma_channels.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\cpu\MKL25Z4.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\cpu\sysinit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\cpu\vectors.h</name>
        </file>
      </group>
      <group>
        <name>drivers</name>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\cmp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\fire_drivers_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\Fire_kinetis_MCG_CFG.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\gpio_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\i2c_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\include.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\lptmr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\mcg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\mcg_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\port.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\rtc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\SPI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\systick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\tick_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\tpm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\tsi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\drivers\uart.h</name>
        </file>
      </group>
      <group>
        <name>platforms</name>
        <file>
          <name>$PROJ_DIR$\..\src\include\platforms\freedom.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\include\platforms\tower.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>other</name>
      <file>
        <name>$PROJ_DIR$\..\src\other\LandzoOLED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\other\LandzoOLED.h</name>
      </file>
    </group>
    <group>
      <name>platforms</name>
    </group>
  </group>
</project>


