<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\plan_manage_main\ewp\plan_manage_main.ewp</path>
  </project>
  <batchBuild/>
</workspace>


